# Keil uVision project LambdaIOT.uvprojx, settings and files
target LambdaIOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4078FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LambdaIOT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4 STDIO _DEBUG
  c include: .\common;.\bsp;.\boot;.\app;.\drivers\include;.\lwip\src\include;.\mbedtls\include;.\lwip-port\lpc407x;.\httpd;.\httpd\cgi
  asm define: EN_CRP1 __VFP_FP__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\LambdaIOT.sct
  group bsp
    ./bsp/: bsp.c bsp.h bsp_phy.c bsp_phy.h
  group boot
    ./boot/: startup_LPC407x_8x.s system_LPC407x_8x.c cpu_s.asm cpu_s.h
  group app
    ./app/: main.c log.c log.h
  group common
    ./common/: mytypes.h
  group drivers
    ./drivers/source/: lpc_emac.c lpc_gpio.c lpc_iap.c lpc_nvic.c lpc_rtc.c lpc_systick.c lpc_timer.c lpc_clkpwr.c lpc_pinsel.c
    ./drivers/include/: lpc_libcfg.h
  group lwip
    ./lwip/src/core/ipv4/: acd.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c tcpip.c
    ./lwip/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c
    ./lwip/src/apps/netbiosns/: netbiosns.c
    ./lwip/src/include/lwip/: arch.h
    ./lwip/src/netif/: ethernet.c
  group mbedtls
    ./mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c common.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_core.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_se.c psa_crypto_se.h psa_crypto_service_integration.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ./mbedtls/include/mbedtls/: config.h ssl.h config_user.h
  group lwip-port
    ./lwip-port/lpc407x/: lwipopts.h lwip_api.c
    ./lwip-port/lpc407x/arch/: sys_arch.c sys_arch.h port_device.c port.h port_file.c cc.h cpu.h
    ./lwip-port/lpc407x/netif/: ethernetif.c ethernetif.h
  group httpd
    ./httpd/: utils.c utils.h http_cgi.c http_cgi.h http_core.c http_core.h http_fs.c http_fs.h http_session.c http_session.h http_web.c http_web.h ssdp.c ssdp.h
    ./httpd/cgi/: cgi_auth.c cgi_files.c cgi_form.c cgi_ssdp.c cgi_ssi.c cgi_upload.c cgi_web.c
target RAM_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USBHostLite +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RAM_MODE__
  c include: .;..\;..\..\..\..\Drivers\include;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\BoardSupport
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4 (ARM-ADS)
  device: LPC4078FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: as above
  output: USBHostLite +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target RAM_M4 (ARM-ADS)
  device: LPC4078FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: as above
  output: USBHostLite +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RAM_MODE__, CORE_M4
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
